PACKAGECONFIG:append:virt-aarch64 = " networkd resolved"