SOFTWARE_VERSION ??= "0.0"

RAUC_BUNDLE_VERSION = "${SOFTWARE_VERSION}"