
IMAGE_INSTALL:append:virt-aarch64 = " \
    alive-service \
"

# Testing support
DEPENDS:append = "labgrid-env-config"