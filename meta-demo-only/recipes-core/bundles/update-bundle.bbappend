BUNDLE_EXTENSION = "-${RELEASE_TYPE}.raucb"