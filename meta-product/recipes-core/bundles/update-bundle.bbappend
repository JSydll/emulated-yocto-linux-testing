RAUC_BUNDLE_VERSION = "${SOFTWARE_VERSION}"