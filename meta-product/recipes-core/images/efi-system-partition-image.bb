SUMMARY = "..."
IMAGE_LINGUAS = " "

LICENSE = "MIT"

inherit core-image

IMAGE_FSTYPES = "wic.qcow2"
WKS_FILE = "efi-system-partition-image.wks"